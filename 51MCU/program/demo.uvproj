# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc;D:\keil c51\C51\INC
  group Source Group 1
    ./: STARTUP.A51
    ../src/: main.c Init.c Timer.c Uart_Init.c shumaguan.c
